## Kconfig
```kconfig
# Copyright (c) 2022 Space Cubics, LLC.
# SPDX-License-Identifier: Apache-2.0

config SIMPLEST
	bool "Most simple Zephyr module"
	help
	  A simple Zephyr module.
```
